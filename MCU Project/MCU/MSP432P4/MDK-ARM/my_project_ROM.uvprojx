# Keil uVision project my_project_ROM.uvprojx, settings and files
target my_project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project_rom
  AfterMake: fromelf --bin --output .\Build\my_project_ROM.bin .\Build\my_project_ROM.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Hardware\Inc;..\SYS\Inc;..\Drivers;..\..\..\DSP_Lib\CMSIS\Include;..\..\..\OLED_Lib;..\..\..\BLL\Inc;..\..\..\BSP\Inc;..\..\MSP432P4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ./: startup_msp432p401r_uvision.s
    ./: system_msp432p401r.c
    ../../../BLL/: main_app.c
  group Library
    ../../../DSP_Lib/CMSIS/DSP_Lib/lib/keil/m4f/: arm_cortexM4lf_math.a
    E:/RNA_2021_Game_A/MCU Project/MCU/MSP432P4/Drivers/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group HARDWARE
    ../Hardware/: adc.c baseboard.c led.c timA.c usart3.c
  group SYS
    ../SYS/: baudrate_calculate.c delay.c sysinit.c usart.c
  group OLED LIB
    ../../../OLED_Lib/: oled_basic.c oled_bmp.c oled_buffer.c oled_color.c oled_config.c oled_debug.c oled_draw.c oled_driver.c oled_font.c
  group BLL
    ../../../BLL/: bll.c log.c oled_interface.c simulation.c
  group BSP
    ../../../BSP/: bsp.c
software components: CMSIS:CORE 4.3.0
